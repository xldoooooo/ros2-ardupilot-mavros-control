Commit message: 260603

File: src/guided_sim/urdf/quadcopter.urdf (robot description, URDF)
Before this commit: robot quadcopter, 6 links, 5 joints
Joints:
- joint fd: origin xyz=0.10 0 0.03 rpy=0 0 0 -> xyz=0.10 0 0.03
